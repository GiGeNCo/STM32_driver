<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\dd.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\inputmode\input.ewp</path>
    </project>
    <batchBuild />
</workspace>
