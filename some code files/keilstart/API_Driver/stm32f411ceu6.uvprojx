# Keil uVision project stm32f411ceu6.uvprojx, settings and files
target STM32F411CEUx (6220000::V6.22::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f411ceu6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\drivers\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c
  group drivers
    ./drivers/Inc/: stm32f411ceux.h gpio_stm32f411ceux.h
    ./drivers/Src/: gpio_stm32f411ceux.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
