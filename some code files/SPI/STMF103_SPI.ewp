# IAR project STMF103_SPI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: myDriver\Inc; ..\..\done\Interrupt\Drivers\CMSIS\Device\ST\STM32F1xx; myDriver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group myDriver/Inc
    myDriver/Inc/: stm32f103c8_SPI.h stm32f103c8xx.h stm32f103c8xx.h_gpio_driver.h
  group myDriver/Src
    myDriver/Src/: stm32f103c8_SPI.c stm32f103c8xx.h_gpio_driver.c
