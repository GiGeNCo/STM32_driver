# IAR project API_Driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE
  ICCARM.CCIncludePath2: stm32f411ceux_driver\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group stm32f411eux_driver/inc
    stm32f411ceux_driver/inc/: gpio_stm32f411ceux.h i2c_stm32f411ceux.h stm32f411ceux.h
  group stm32f411eux_driver/src
    stm32f411ceux_driver/src/: gpio_stm32f411ceux.c i2c_stm32f411ceux.c
